options:
  parameters:
    author: elof
    comment: ffmpeg -v 0 -i quickie.mp4 -vf scale=720:576 -c:v rawvideo -pix_fmt yuv420p -f rawvideo pipe:1 | python pal_fm_tx.py
    generate_options: qt_gui
    id: pal_fm_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fc
  id: variable_qtgui_entry
  parameters:
    label: Fc
    type: real
    value: vc_fc
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: IF Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '47'
    value: vc_if
  states: {}
- name: rf_gain
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: RF Gain
    'true': '1'
    type: int
    value: vc_rf
  states: {}
- name: sens
  id: variable_qtgui_entry
  parameters:
    label: Sensitivity
    type: real
    value: vc_sens
  states: {}
- name: vc_fc
  id: variable_config
  parameters:
    config_file: settings_pal
    option: '"fc"'
    section: '"main"'
    type: real
    value: 5800e6
    writeback: fc
  states: {}
- name: vc_if
  id: variable_config
  parameters:
    config_file: settings_pal
    option: '"if"'
    section: '"main"'
    type: int
    value: '0'
    writeback: if_gain
  states: {}
- name: vc_rf
  id: variable_config
  parameters:
    config_file: settings_pal
    option: '"rf"'
    section: '"main"'
    type: int
    value: '1'
    writeback: rf_gain
  states: {}
- name: vc_sens
  id: variable_config
  parameters:
    config_file: settings_pal
    option: '"fmgain"'
    section: '"main"'
    type: real
    value: '1'
    writeback: sens
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: sens
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: 2**8
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: 2**8
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2**-8
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: 1280*2
    srate: 20e6
    type: float
    ymax: '0.8'
    ymin: '-.4'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '5'
    taps: ''
    type: fff
  states: {}
- name: soapy_sink_0
  id: soapy_sink
  parameters:
    amp_gain0: rf_gain
    ant0: '"TX/RX"'
    center_freq0: fc
    devname: hackrf
    samp_rate: 20e6
    type: fc32
    vga_gain0: if_gain
  states: {}
- name: yuv576i2pal_0
  id: yuv576i2pal
  parameters: {}
  states: {}
- name: yuv_to_576i_0
  id: yuv_to_576i
  parameters:
    height: '576'
    width: '720'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', soapy_sink_0, '0']
- [blocks_char_to_float_0, '0', yuv576i2pal_0, '1']
- [blocks_char_to_float_1, '0', yuv576i2pal_0, '2']
- [blocks_file_descriptor_source_0, '0', yuv_to_576i_0, '0']
- [blocks_multiply_const_vxx_0, '0', yuv576i2pal_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [yuv576i2pal_0, '0', rational_resampler_xxx_0, '0']
- [yuv_to_576i_0, '0', blocks_uchar_to_float_0, '0']
- [yuv_to_576i_0, '1', blocks_char_to_float_0, '0']
- [yuv_to_576i_0, '2', blocks_char_to_float_1, '0']

metadata:
  file_format: 1
