options:
  parameters:
    generate_options: hb
    id: yuv_to_576i
    output_language: python
    title: YUV420 to 576i (625)
  states: {}

blocks:
- name: u
  id: variable
  parameters:
    value: y//4
  states: {}
- name: v
  id: variable
  parameters:
    value: y//4
  states: {}
- name: y
  id: variable
  parameters:
    value: width*height
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: y
    n: y+u+v
    offset: '0'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: u
    n: y+u+v
    offset: y
    type: byte
  states: {}
- name: blocks_keep_m_in_n_2
  id: blocks_keep_m_in_n
  parameters:
    m: v
    n: y+u+v
    offset: y+u
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: byte
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '2'
    type: byte
  states: {}
- name: blocks_repeat_2
  id: blocks_repeat
  parameters:
    interp: '2'
    type: byte
    vlen: '720'
  states: {}
- name: blocks_repeat_3
  id: blocks_repeat
  parameters:
    interp: '2'
    type: byte
    vlen: '720'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '720'
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '720'
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '720'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '720'
    type: byte
  states: {}
- name: height
  id: parameter
  parameters:
    label: Height
    value: '576'
  states: {}
- name: line720_1024interleaved_0
  id: line720_1024interleaved
  parameters: {}
  states: {}
- name: line720_1024interleaved_1
  id: line720_1024interleaved
  parameters: {}
  states: {}
- name: line720_1024interleaved_2
  id: line720_1024interleaved
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: y
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: u
    type: byte
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: v
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: uv_fix_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='uv fix',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]-128
              return len(output_items[0])
  states: {}
- name: uv_fix_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self,):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='uv fix',   # will show up in GRC
                  in_sig=[np.uint8],
                  out_sig=[np.int8]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]-128
              return len(output_items[0])
  states: {}
- name: width
  id: parameter
  parameters:
    label: Width
    type: intx
    value: '720'
  states: {}

connections:
- [blocks_keep_m_in_n_0, '0', line720_1024interleaved_0, '0']
- [blocks_keep_m_in_n_1, '0', uv_fix_0, '0']
- [blocks_keep_m_in_n_2, '0', uv_fix_1, '0']
- [blocks_repeat_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_repeat_1, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_repeat_2, '0', blocks_vector_to_stream_0, '0']
- [blocks_repeat_3, '0', blocks_vector_to_stream_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_repeat_2, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_repeat_3, '0']
- [blocks_vector_to_stream_0, '0', line720_1024interleaved_1, '0']
- [blocks_vector_to_stream_1, '0', line720_1024interleaved_2, '0']
- [line720_1024interleaved_0, '0', pad_sink_0, '0']
- [line720_1024interleaved_1, '0', pad_sink_1, '0']
- [line720_1024interleaved_2, '0', pad_sink_2, '0']
- [pad_source_0, '0', blocks_keep_m_in_n_0, '0']
- [pad_source_0, '0', blocks_keep_m_in_n_1, '0']
- [pad_source_0, '0', blocks_keep_m_in_n_2, '0']
- [uv_fix_0, '0', blocks_repeat_0, '0']
- [uv_fix_1, '0', blocks_repeat_1, '0']

metadata:
  file_format: 1
