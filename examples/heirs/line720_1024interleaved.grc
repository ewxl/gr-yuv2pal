options:
  parameters:
    generate_options: hb
    id: line720_1024interleaved
    output_language: python
    title: 720 to 1024 interleaved
  states: {}

blocks:
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: 625*1024
    n: 628*1024
    offset: '0'
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0_1
  id: blocks_null_source
  parameters:
    type: byte
    vlen: '1024'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: 600*1024
    type: byte
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[242,720,62]'
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: '[576,26*2]'
    type: byte
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '628'
    type: byte
    vlen: '1024'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: byte
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '628'
    type: byte
    vlen: '1024'
  states: {}
- name: interleaver625
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='interleaver',   # will show up in GRC
                  in_sig=[np.dtype("643072B")],
                  out_sig=[np.dtype("643072B")]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

          def work(self, input_items, output_items):
              """example: multiply with constant"""

              for i,frame in enumerate(input_items[0]):
                  frame = frame.reshape(628,1024)
                  out = output_items[0][i].reshape(628,1024)
                  out[:] = 0

                  out[:625//2] = frame[:624:2]
                  out[625//2+1:625] = frame[1:624:2]

              return len(output_items[0])
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_keep_m_in_n_1, '0', blocks_skiphead_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '2']
- [blocks_null_source_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_null_source_0_1, '0', blocks_stream_mux_0_0, '1']
- [blocks_skiphead_0, '0', pad_sink_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_stream_mux_0_0, '0']
- [blocks_stream_to_vector_1, '0', interleaver625, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_1, '0']
- [blocks_vector_to_stream_1, '0', blocks_vector_to_stream_0, '0']
- [interleaver625, '0', blocks_vector_to_stream_1, '0']
- [pad_source_0, '0', blocks_stream_mux_0, '1']

metadata:
  file_format: 1
